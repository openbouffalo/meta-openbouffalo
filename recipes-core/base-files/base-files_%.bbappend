FILESEXTRAPATHS:prepend := "${THISDIR}/base-files:"

SRC_URI += "file://fstab"